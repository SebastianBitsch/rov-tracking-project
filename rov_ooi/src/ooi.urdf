Commit message: made sphere larger

File: rov_ooi/src/ooi.urdf (robot description, URDF)
Before this commit: robot simple_ball, 1 links, 0 joints
Links:
- link ball: geometry collision sphere radius=1.0; visual sphere radius=1.0
